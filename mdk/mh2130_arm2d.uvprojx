# Keil uVision project mh2130_arm2d.uvprojx, settings and files
target MH2103-for-arm2d (6240000::V6.24::.\ArmCompilerforEmbedded6.24)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.1.9
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mh2130_arm2d
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\MH210xLib\inc;..\Libraries\CORE;..\source\driver;..\source\driver\lcd;..\source\driver\modbus;..\source\driver\uart;..\source\system;..\source\application\arm2d_scene;..\Libraries\MH210xLib\lib;..\source\gui;..\source
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group library
    ../Libraries/MH210xLib/src/: mh210x_adc.c mh210x_bkp.c mh210x_can.c mh210x_crc.c mh210x_dac.c mh210x_dbgmcu.c mh210x_dma.c mh210x_exti.c mh210x_flash.c mh210x_fsmc.c mh210x_gpio.c mh210x_i2c.c mh210x_iwdg.c mh210x_otp.c mh210x_pwr.c mh210x_rcc.c mh210x_rtc.c mh210x_sdio.c mh210x_spi.c mh210x_tim.c mh210x_trng.c mh210x_usart.c mh210x_wwdg.c misc.c system_mh210x.c
  group lib
    ../source/lib/: guilib.lib
    ../Libraries/MH210xLib/lib/: mh2103.lib
  group driver
    ../source/driver/: drv_buzzer.c drv_flash.c drv_key.c drv_rtc.c drv_timer.c
  group driver/lcd
    ../source/driver/lcd/: drv_lcd.c lcd1_if_mcu8.c lcd1_ST7789P3_mcu_002.c
  group driver/modbus
    ../source/driver/modbus/: mb_crc.c mb_rtu.c
  group driver/uart
    ../source/driver/uart/: drv_uart_mcu.c uart_debug.c
  group system
    ../source/system/: debug.c system.c
    ../Libraries/CORE/: mh210x_it.c startup_mh210x.s
  group application
    ../source/system/: main.c
    ../source/: wedge_pattern.c radial_line_pattern.c radial_line_cover.c arm_2d_scene_knob.c knob_circle_quater.c arm_2d_scene_fan.c arm_2d_scene_watch.c arm_2d_scene_alarm_clock.c arm_2d_scene_fitness.c arm_2d_scene_histogram.c arm_2d_scene_meter.c MeterPanel.c
software components: Acceleration:Arm-2D Demos:Compass 1.2.1, Acceleration:Arm-2D Demos:Decoding JPG with TJpgDec 0.9.1, Acceleration:Arm-2D Demos:Filters 1.2.1, Acceleration:Arm-2D Demos:Gas Gauge 1.1.1, Acceleration:Arm-2D Demos:Text Reader 0.9.1, Acceleration:Arm-2D Extras:Controls 2.4.5, Acceleration:Arm-2D Extras:LCD ASCII Printf 2.10.2, Acceleration:Arm-2D Extras:TJpgDec Loader 0.9.5, Acceleration:Arm-2D Helper:Display Adapter 3.3.1, Acceleration:Arm-2D Helper:PFB 2.5.5, Acceleration:Arm-2D:Alpha-Blending 1.2.2-dev, Acceleration:Arm-2D:Core 1.2.2-dev, Acceleration:Arm-2D:Filter 1.2.2-dev, Acceleration:Arm-2D:Transform 1.2.2-dev, CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Display Adapter 0 1.0.1, CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2, Utilities:perf_counter:Core 2.4.0
